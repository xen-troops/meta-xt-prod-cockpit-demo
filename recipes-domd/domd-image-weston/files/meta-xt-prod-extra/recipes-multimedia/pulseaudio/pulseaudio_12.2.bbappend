FILESEXTRAPATHS_append := "${THISDIR}/files:"

SRC_URI_append_h3ulcb-4x2g-kf-xt = " \
    file://alsa-util-patch-to-disable-large-number-error.patch \
"
