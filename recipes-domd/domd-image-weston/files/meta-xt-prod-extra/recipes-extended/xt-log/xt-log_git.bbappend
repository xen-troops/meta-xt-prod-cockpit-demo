SRC_URI = "git://github.com/xen-troops/${PN}.git;protocol=https"
SRCREV = "${AUTOREV}"
